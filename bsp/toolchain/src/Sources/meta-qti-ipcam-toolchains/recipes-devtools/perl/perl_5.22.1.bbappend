FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://posix-guard-fenv.patch"

