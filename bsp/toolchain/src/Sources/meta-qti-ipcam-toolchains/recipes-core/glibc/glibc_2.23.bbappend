FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-regexp-avoid-common-symbols-for-compat_symbol.patch"

