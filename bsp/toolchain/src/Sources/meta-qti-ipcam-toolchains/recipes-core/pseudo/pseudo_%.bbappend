# Workaround: fixed build error for nativesdk-pseudo
CFLAGS_append_class-nativesdk = " -fcommon"

